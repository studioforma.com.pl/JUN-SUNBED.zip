Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [TrimBim], ExchangeRequirement [Any]
File name: Jun-Sunbed - ver4.ifc
Time: 2024-11-07T18:00:57
Author: Utente
Organization: Trimble
Written by: Trimble SketchUp
Made in: Trimble SketchUp
Authorization: IFC4 model

# IfcBuildingElementProxy (11)
Name
 | Jun-Sunbed_0 - ObjectType: SketchupGroup
 | Jun-Sunbed_1 - ObjectType: SketchupGroup
 | Jun-Sunbed_2 - ObjectType: SketchupGroup
 | Jun-Sunbed_3 - ObjectType: SketchupGroup
 | Jun-Sunbed_4 - ObjectType: SketchupGroup
 | Jun-Sunbed_5 - ObjectType: SketchupGroup
 | Jun-Sunbed_6 - ObjectType: SketchupGroup
 | Jun-Sunbed_7 - ObjectType: SketchupGroup
 | Jun-Sunbed_8 - ObjectType: SketchupGroup
 | Jun-Sunbed_9 - ObjectType: SketchupGroup
 | Jun-Sunbed_10 - ObjectType: SketchupGroup
